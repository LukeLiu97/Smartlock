# Keil uVision project SmartLock.uvprojx, settings and files
target Debug_SmartLock (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smartlock
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,DEBUG
  c include: ..\CMSIS;..\Std_Library\inc;..\BSD\Include;..\User\Include;..\GUI\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/Source/: font.c main.c stm32f10x_it.c ui.c user_string.c global.c
  group GUI
    ../GUI/Include/: gui.h
    ../GUI/Source/: gui_finger.c gui_password.c gui_baseelmt.c
  group BoardSupportDrive
    ../BSD/Source/: iic.c key.c led.c mpr121.c oled.c systick.c time.c uart.c voice.c tim.c finger.c motor.c rfid.c
  group Std_Library
    ../Std_Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: system_stm32f10x.c core_cm3.c startup_stm32f10x_md.s
  group Documents
    ../Documents/: DevelopLog.md
